# Keil uVision project MiaoA.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: SWM181xC Synwit
  pack: Synwit.SWM32_DFP.1.20.3
  cpu: IROM(0x00000000,0x3E000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MiaoA +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\MPU6050;.\HARDWARE\OLED;.\Basic\delay;.\HARDWARE\LED;.\Basic\uart;.\HARDWARE\MPU6050;.\HARDWARE\MPU6050\eMPL;.\HARDWARE\MPU6050\eMPL
  memory RVCT4: ROM 0x0 size 0x3e000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group usr
    ./: main.c gpio.h
  group HARDWARE
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ./HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/uart/: uart.c
software components: CMSIS:CORE 5.4.0, Device:Driver:ADC 1.6.0, Device:Driver:DMA 1.6.0, Device:Driver:GPIO 1.6.0, Device:Driver:I2C 1.6.0, Device:Driver:IRQMux 1.6.0, Device:Driver:PWM 1.6.0, Device:Driver:Port 1.6.0, Device:Driver:SDADC 1.6.0, Device:Driver:SLCD 1.6.0, Device:Driver:SPI 1.6.0, Device:Driver:Timer 1.6.0, Device:Driver:UART 1.6.0, Device:Startup 1.6.0
